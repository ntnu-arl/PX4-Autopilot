## src/modules/obstacle_aggregator/Kconfig
```kconfig
menuconfig MODULES_OBSTACLE_AGGREGATOR
	bool "obstacle_aggregator"
	default n
	---help---
		Enable support for obstacle_aggregator
```
